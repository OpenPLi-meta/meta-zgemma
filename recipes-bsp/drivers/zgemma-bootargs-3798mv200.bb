SRCDATE = "20200916"

require zgemma-bootargs.inc

SRC_URI[md5sum] = "${BOOTARGS_MD5}"
SRC_URI[sha256sum] = "${BOOTARGS_SHA256}"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"

BOOTARGS_MD5 = "378622e172cb6c70d50c988badf30a04"
BOOTARGS_MD5_h8se = "c6edf9e030b4f041c1d515f45f297453"

BOOTARGS_SHA256 = "cfe68f0a7248af35f42ea74f13b2fdbbec7b9682940f9725da914c44f5a05f5f"
BOOTARGS_SHA256_h8se = "b32827c129edc0fa9ee95191d9af4758725941c05dda603f3fbd7a85e40b48f0"

SRCDATE_h8se = "20261009"
