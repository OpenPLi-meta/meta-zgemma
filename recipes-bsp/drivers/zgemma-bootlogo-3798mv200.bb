SRCDATE = "20200916"

require zgemma-bootlogo.inc

SRC_URI[md5sum] = "${BOOTLOGO_MD5}"
SRC_URI[sha256sum] = "${BOOTLOGO_SHA256}"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"

BOOTLOGO_MD5 = "a4be4429300800b3901c85ef8af95037"
BOOTLOGO_MD5_h8se = "69bab9c1c236813e76448bd448c698f0"

BOOTLOGO_SHA256 = "56acac6f3f23a7769a6f489658d14e78c7803b707fb6712b15c02cd7f1399671"
BOOTLOGO_SHA256_h8se = "364f3b26eb005f6ad2ad78a6ed104a1fa4e43679de9722142222a56372a06632"

SRCDATE_h8se = "20261009"
